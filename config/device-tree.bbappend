SRC_URI += " \
	file://system-user.dtsi \
	file://0001-Fix-the-issue-when-mappings-are-not-updated.patch \
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
