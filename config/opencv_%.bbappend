# opencv_%.bbappend
PACKAGECONFIG_append = "libv4l libav"
